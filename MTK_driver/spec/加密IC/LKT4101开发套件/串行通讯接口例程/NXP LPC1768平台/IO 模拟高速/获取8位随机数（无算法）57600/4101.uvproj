# Keil uVision project 4101.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: 4101 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    E:/路虎开发版资料/实验例程/GPIO/Source/CMSIS/: system_LPC17xx.c
    E:/路虎开发版资料/实验例程/GPIO/Source/CMSIS/startup/arm/: startup_LPC17xx.s
  group APP
    ./: 4101.c
